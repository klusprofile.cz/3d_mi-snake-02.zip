Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: fcb9c39f-157f-4977-b28d-f18ec66ce5b7, NumberOfSaves: 15], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project Number
Time: 2023-12-19T11:11:29+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.0.63 (ENU) - IFC 24.1.1.6

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcDistributionPort, Port_328321_1
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: KLUŚ - MIFOR - MI-SNAKE-02:Silver anodized - 3000 K - 6320 lm, KLUŚ - MIFOR - MI-SNAKE-02:Silver anodized - 3000 K - 6320 lm:328321
In: Level 0
Type - Material: Steel, Aluminum, Silver Anodized, PC - 3000 K
Type - Other - Category: Lighting Fixtures; Color: silver anodized; Control: ON/OFF; Cover: frosted; Dimensions L x W x H: 2242.4 x 572.3 x 87.2; Family Name: KLUŚ - MIFOR - MI-SNAKE-02; Lighting direction: down; Material: aluminum; Mounting type: suspended; Weight: 5.2 kg; Working temperature: 10°C - 30°C
Type - Constraints - Cord length max: 3000 mm; Cord length min: 100 mm; Default Elevation: 0 mm
Type - Data - Color rendering index: 90 CRI; Color temperature: 3000 K; Efficiency: 90 lm/W; IP protection rating: IP20; Luminare power: 70 W; Luminous flux of the fixture: 6320 lm; MacAdam’s ellipse: 3 SDCM; Protection class: III; Supply voltage: 24 V
Type - Dimensions - Light Source Symbol Size: 100 mm
Type - Electrical - Loads - Apparent Load: 70 W; Input voltage: 24 V; Power consumption: 70 W; Power factor: 1
Type - General - OmniClassCode: 23.80.70.11.14.11; OmniClassTitle: Downlights; Uniclass2015Code: Pr_70_70_48_24; Uniclass2015Title: Downlights; Uniclass2015Version: Products v1.31
Type - Identity Data - Author: www.archispace.pl; Manufacturer: KLUŚ Sp. z o.o.; Model: MI-SNAKE-02; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Ref No: FPMI042-01300B; System: MIFOR-70; Type Name: Silver anodized - 3000 K - 6320 lm; URL: https://klusdesign.eu/en
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Emit from Rectangle Length: 2200 mm; Emit from Rectangle Width: 550 mm; Emit Shape Visible in Rendering: no; Illuminance: 216.54 lx; Initial Color Temperature: 3000 K; Light Source Definition (family): Rectangle+HemiSpherical; Luminous Flux: 6320 lm; Luminous Intensity: 2011.72 cd; Total Light Loss Factor: 1; Wattage: 42.5469 W
Type - Materials and Finishes - Body material: Aluminum, Silver Anodized; Diffuser material: PC - 3000 K
Type - Pset_ElementShading - Color: silver anodized
Type - Pset_ManufacturerTypeInformation - Manufacturer: KLUŚ Sp. z o.o.
Pset_DistributionFlowElementCommon - Reference: KLUŚ - MIFOR - MI-SNAKE-02:Silver anodized - 3000 K - 6320 lm; sets with these values: 2
Other - Family: KLUŚ - MIFOR - MI-SNAKE-02; Family and Type: KLUŚ - MIFOR - MI-SNAKE-02: Silver anodized - 3000 K - 6320 lm; Type: Silver anodized - 3000 K - 6320 lm; Type Id: 328282
Constraints - Elevation from Level: 555 mm; Host: Reference Plane; Level: Level 0; Offset from the ceiling - desired: 500 mm; Offset from the ceiling - real: 500 mm; Schedule Level: Level 0
Dimensions - Area: 2.07334 m2; Volume: 0.0911485 m3
Electrical - Circuiting - Electrical Data: 24.00 V 24 V/1-70 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 16
Phasing - Phase Created: New Construction
